# IAR project PhysiologicalTests.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_uart_int.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: PhysiologicalTests.srec
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources/C
    src/Sources/C/: isr.c main.c
  group Sources/C/Component_C
    src/Sources/C/Component_C/: adc.c button.c Command_analy.c control.c decoder.c delay.c gpio.c i2c.c light.c LQ12864.c MMA8451.c NRF24L01.c PID.c pit.c pwm.c uart.c UpMonitor.c wdog.c
  group Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Sources/H
    src/Sources/H/: includes.h
  group Sources/H/Component_H
    src/Sources/H/Component_H/: adc.h button.h Command_analy.h control.h decoder.h delay.h gpio.h i2c.h light.h LQ12864.h MMA8451.h NRF24L01.h PID.h pit.h pwm.h uart.h UpMonitor.h wdog.h
  group Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
